# Keil uVision project ble_ant_app_hrm.uvproj, settings and files
target nrf51422_xxaa_s310 (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: IRAM(0x20002800-0x20003FFF) IROM(0x20000-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_ant_app_hrm +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER,BLE_STACK_SUPPORT_REQD,ANT_STACK_SUPPORT_REQD, BOARD_PCA10003
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s310;..\..\..\..\..\Include\sd_common;..\..\ble_ant_app_hrm
  memory RVCT4: ROM 0x20000 size 0x1f000
  memory RVCT9: RAM 0x20002400 size 0x1c00
  group Startup Code
    ./../../../../../Source/templates/arm/: arm_startup_nrf51422_s310.s
    ./../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
    ../: ant_hrm_rx.c
  group Services
    ../../../../../Source/ble/ble_services/: ble_dis.c ble_hrs.c
  group Libraries
    ../../../../../Source/ble/: ble_error_log.c ble_advdata.c ble_sensorsim.c ble_conn_params.c ble_bondmngr.c ble_debug_assert_handler.c
    ../../../../../Source/ble/ble_services/: ble_srv_common.c
    ../../../../../Source/app_common/: app_timer.c crc16.c pstorage.c
    ../../../../../Source/sd_common/: softdevice_handler.c
