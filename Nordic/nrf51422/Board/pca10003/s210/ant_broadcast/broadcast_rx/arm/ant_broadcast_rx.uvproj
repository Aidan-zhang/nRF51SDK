# Keil uVision project ant_broadcast_rx.uvproj, settings and files
target nrf51422_xxaa_s210 (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.0.3
  cpu: IRAM(0x20000800-0x20003FFF) IROM(0xA000-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ant_broadcast_rx +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51 BOARD_PCA10003
  c misc: --c99
  c include: ..\..\..\..\..\..\Include;..\..\..\..\..\..\Include\s210;..\..\..\..\..\..\Include\app_common
  memory RVCT4: ROM 0xc000 size 0x34000
  memory RVCT9: RAM 0x20000900 size 0x3700
  group src
    ../: main_broadcast_rx.c
  group core
    ../../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../../../Source/templates/: system_nrf51422.c
    ../../../../../../Source/nrf_delay/: nrf_delay.c
