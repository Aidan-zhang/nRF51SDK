# Keil uVision project blinky.uvproj, settings and files
target nrf51422_xxaa (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.0.3
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: blinky_arm +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_PCA10003
  c misc: --c99
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../: main.c
    ../../../../Source/: keil_arm_uv4.lnt
  group core
    ../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../Source/templates/: system_nrf51.c
  group lib
    ../../../../Source/nrf_delay/: nrf_delay.c
target nrf51422_xxaa_s210 (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.0.3
  cpu: as above
  output: blinky_arm +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_PCA10003
  c misc: --c99
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0xc000 size 0x34000
  memory RVCT9: RAM 0x20000900 size 0x3700
target nrf51422_xxaa_s310 (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.0.3
  cpu: as above
  output: blinky_arm +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_PCA10003
  c misc: --c99
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x20000 size 0x1f000
  memory RVCT9: RAM 0x20002400 size 0x1c00
