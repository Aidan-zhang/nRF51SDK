# Keil uVision project ble_app_hrs.uvproj, settings and files
target nrf51422_xxaa_s310 (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: ble_app_hrs +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\device_manager;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s310;..\..\..\..\..\Include\sd_common;..\..\..\..\..\Include\sdk
  memory RVCT4: ROM 0x20000 size 0x1f000
  memory RVCT9: RAM 0x20002400 size 0x1c00
  group Startup Code
    ./../../../../../Source/templates/: system_nrf51.c
    ../../../../../Source/templates/arm/: arm_startup_nrf51422_s310.s
  group Source Code
    ./../: main.c
  group Services
    ../../../../../Source/ble/ble_services/: ble_dis.c ble_bas.c ble_hrs.c
  group Libraries
    ../../../../../Source/ble/: ble_error_log.c ble_advdata.c ble_sensorsim.c ble_conn_params.c ble_debug_assert_handler.c
    ../../../../../Source/ble/ble_services/: ble_srv_common.c
    ../../../../../Source/app_common/: app_timer.c app_trace.c pstorage.c crc16.c
    ../../../../../Source/sd_common/: softdevice_handler.c
    ../../../../../Source/simple_uart/: simple_uart.c
    ../../../../../Source/ble/device_manager/: device_manager_peripheral.c
